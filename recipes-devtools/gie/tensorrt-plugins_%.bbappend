# PACKAGECONFIG:remove = "parsers"
