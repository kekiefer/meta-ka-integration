FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-Disable-runtime_lib_dirs-to-support-cross-compilatio.patch"

