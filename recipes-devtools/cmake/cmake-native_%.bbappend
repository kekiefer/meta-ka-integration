FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-cuda-honor-CUDAFLAGS-for-detection-during-enab.patch"

